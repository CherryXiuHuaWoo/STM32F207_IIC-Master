# Keil uVision project STM32F207_IIC-Master.uvprojx, settings and files
target STM32F207_IIC-Master (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32F207_IIC-Master
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32F2xx_HAL_Driver/Inc;  ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F2xx/Include;  ../Drivers/CMSIS/Include;  ..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_flash_ex.c stm32f2xx_hal.c stm32f2xx_hal_flash.c stm32f2xx_hal_uart.c stm32f2xx_hal_i2c.c stm32f2xx_hal_tim.c stm32f2xx_hal_dma.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_cortex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma_ex.c
  group Application/User
    ../Src/: usart.c gpio.c stm32f2xx_hal_msp.c i2c.c stm32f2xx_it.c main.c dma.c
    ../User/: User_Commands.c User_IIC.c User_Task.c
software components: CMSIS:CORE 4.1.0
